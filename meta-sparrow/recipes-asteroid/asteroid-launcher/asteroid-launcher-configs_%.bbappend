FILESEXTRAPATHS:prepend:sparrow := "${THISDIR}/asteroid-launcher-configs:"
