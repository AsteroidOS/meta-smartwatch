FILESEXTRAPATHS:prepend:sparrow := "${THISDIR}/${PN}:"
