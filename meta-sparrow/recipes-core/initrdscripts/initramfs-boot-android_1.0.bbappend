FILESEXTRAPATHS_prepend_sparrow := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_sparrow = "sparrow"
