FILESEXTRAPATHS:prepend:sparrow := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:sparrow = "sparrow"
