FILESEXTRAPATHS:prepend:sparrow := "${THISDIR}/${PN}:"
FILESEXTRAPATHS:prepend:sparrow-mainline := "${THISDIR}/${PN}-mainline:"
COMPATIBLE_MACHINE:sparrow = "sparrow"
COMPATIBLE_MACHINE:sparrow-mainline = "sparrow-mainline"
