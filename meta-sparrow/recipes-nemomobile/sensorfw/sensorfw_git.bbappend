DEPENDS:append:sparrow = " libhybris "
