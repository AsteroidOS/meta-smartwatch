FILESEXTRAPATHS:prepend:sparrow-mainline := "${THISDIR}/usb-moded:"
