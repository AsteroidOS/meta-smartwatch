RDEPENDS:${PN}:append:sparrow = " qt6-qpa-hwcomposer-plugin "
