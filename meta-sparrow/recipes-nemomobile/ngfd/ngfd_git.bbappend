RDEPENDS_${PN}_append_sparrow = " ngfd-plugin-droid-vibrator "
