RDEPENDS_${PN}_append_sparrow = "qt5-feedback-haptics-droid-vibrator"
