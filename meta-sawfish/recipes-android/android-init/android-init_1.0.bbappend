FILESEXTRAPATHS:prepend:sawfish := "${THISDIR}/${PN}:"
