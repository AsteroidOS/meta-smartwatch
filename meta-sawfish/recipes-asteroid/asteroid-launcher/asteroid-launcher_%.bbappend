FILESEXTRAPATHS:prepend:sawfish := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:sawfish = " file://default.conf"
