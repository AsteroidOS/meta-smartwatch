FILESEXTRAPATHS:prepend:sawfish := "${THISDIR}/asteroid-launcher-configs:"
