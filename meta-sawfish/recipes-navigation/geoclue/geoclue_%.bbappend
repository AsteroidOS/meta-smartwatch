RDEPENDS:${PN}:append:sawfish = " geoclue-provider-hybris-hal "
