do_configure_prepend() {
	touch src/common/droid-util-51.h
}
