RDEPENDS:${PN}:append:sawfish = " qt6-qpa-hwcomposer-plugin "
