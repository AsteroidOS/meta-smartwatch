RDEPENDS:${PN}:append:sawfish = " ngfd-plugin-droid-vibrator "
