FILESEXTRAPATHS_prepend_bass := "${THISDIR}/${PN}:"
