FILESEXTRAPATHS:prepend:bass := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:bass = "bass"
