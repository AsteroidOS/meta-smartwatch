FILESEXTRAPATHS_prepend_bass := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_bass = "bass"
