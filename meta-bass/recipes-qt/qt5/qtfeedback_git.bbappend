RDEPENDS_${PN}_append_bass = "qt5-feedback-haptics-droid-vibrator"
