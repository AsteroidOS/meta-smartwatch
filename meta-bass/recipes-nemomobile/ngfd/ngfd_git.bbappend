RDEPENDS_${PN}_append_bass = " ngfd-plugin-droid-vibrator "
