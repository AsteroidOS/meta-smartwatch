RDEPENDS:${PN}:append:bass = " qt6-qpa-hwcomposer-plugin "
