RDEPENDS:${PN}:append:bass = " qt5-qpa-hwcomposer-plugin "
