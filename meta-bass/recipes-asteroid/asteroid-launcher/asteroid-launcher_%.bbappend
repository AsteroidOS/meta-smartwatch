FILESEXTRAPATHS_prepend_bass := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_bass = " file://default.conf"
