FILESEXTRAPATHS:prepend:bass := "${THISDIR}/asteroid-launcher-configs:"
