FILESEXTRAPATHS:prepend:beluga := "${THISDIR}/asteroid-launcher-configs:"
