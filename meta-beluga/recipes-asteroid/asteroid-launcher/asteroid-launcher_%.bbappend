FILESEXTRAPATHS:prepend:beluga := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:beluga = " file://default.conf"
