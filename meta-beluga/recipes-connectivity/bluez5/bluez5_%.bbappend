FILESEXTRAPATHS:prepend:beluga := "${THISDIR}/bluez5:"
