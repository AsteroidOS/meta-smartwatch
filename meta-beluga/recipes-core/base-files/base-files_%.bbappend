FILESEXTRAPATHS:prepend:beluga := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:beluga = "beluga"
