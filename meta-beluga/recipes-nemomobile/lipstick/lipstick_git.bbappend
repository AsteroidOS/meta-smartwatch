RDEPENDS:${PN}:append:beluga = " qt6-qpa-hwcomposer-plugin "
