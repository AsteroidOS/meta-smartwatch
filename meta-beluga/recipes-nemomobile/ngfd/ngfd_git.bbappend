RDEPENDS:${PN}:append:beluga = " ngfd-plugin-droid-vibrator "
