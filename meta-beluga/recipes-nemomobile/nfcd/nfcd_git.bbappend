RDEPENDS:${PN}:append:beluga = " nfcd-binder-plugin "
