RDEPENDS:${PN}:append:beluga = " geoclue-provider-hybris-binder "
