RDEPENDS:pulseaudio-server:remove:beluga = " pulseaudio-modules-droid "
