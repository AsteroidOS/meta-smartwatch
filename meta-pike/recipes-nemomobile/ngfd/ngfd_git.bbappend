RDEPENDS:${PN}:append:pike = " ngfd-plugin-droid-vibrator "
