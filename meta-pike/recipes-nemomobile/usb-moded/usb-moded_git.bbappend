FILESEXTRAPATHS:prepend:pike := "${THISDIR}/usb-moded:"
