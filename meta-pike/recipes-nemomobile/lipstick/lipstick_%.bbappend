RDEPENDS:${PN}:append:pike = " qt5-qpa-hwcomposer-plugin "
