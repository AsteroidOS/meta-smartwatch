RDEPENDS:${PN}:append:pike = " qt6-qpa-hwcomposer-plugin "
