RDEPENDS:${PN}:append:pike = " geoclue-provider-hybris-hal "
