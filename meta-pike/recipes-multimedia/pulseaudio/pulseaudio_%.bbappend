RDEPENDS:pulseaudio-server:remove:pike= " pulseaudio-modules-droid-jb2q "
