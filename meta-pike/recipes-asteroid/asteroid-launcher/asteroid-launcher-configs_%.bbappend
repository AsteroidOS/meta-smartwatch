FILESEXTRAPATHS:prepend:pike := "${THISDIR}/asteroid-launcher-configs:"
