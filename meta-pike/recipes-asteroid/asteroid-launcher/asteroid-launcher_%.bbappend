FILESEXTRAPATHS:prepend:pike := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:pike = " file://default.conf"
