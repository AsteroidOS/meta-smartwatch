SRC_URI:append:pike = " file://0002-egl-Adapt-wayland-egl-to-upstream-and-use-upstream-w.patch;striplevel=2 \
                            file://0003-hybris-gles-Add-GLESv3-headers.patch;striplevel=2 "
