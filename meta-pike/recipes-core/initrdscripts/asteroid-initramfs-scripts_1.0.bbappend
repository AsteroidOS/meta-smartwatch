FILESEXTRAPATHS:prepend:pike := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:pike = "pike"
