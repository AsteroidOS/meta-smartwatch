DEPENDS:append:rubyfish = " neard "
RDEPENDS:${PN}:append:rubyfish = " nfcd-binder-plugin "
