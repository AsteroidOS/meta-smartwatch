RDEPENDS:${PN}:append:rubyfish = " qt5-qpa-hwcomposer-plugin "
