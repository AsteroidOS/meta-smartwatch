RDEPENDS:${PN}:append:rubyfish = " qt6-qpa-hwcomposer-plugin "
