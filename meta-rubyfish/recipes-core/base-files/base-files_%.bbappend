FILESEXTRAPATHS:prepend:rubyfish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:rubyfish = "rubyfish"
