FILESEXTRAPATHS:prepend:rubyfish := "${THISDIR}/${PN}:"
