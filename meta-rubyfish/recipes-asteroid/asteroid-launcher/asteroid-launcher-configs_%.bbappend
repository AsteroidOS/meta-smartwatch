FILESEXTRAPATHS:prepend:rubyfish := "${THISDIR}/asteroid-launcher-configs:"
