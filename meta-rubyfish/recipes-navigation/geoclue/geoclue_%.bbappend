RDEPENDS:${PN}:append:rubyfish = " geoclue-provider-hybris-binder "
