FILESEXTRAPATHS:prepend:dory := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:dory = " file://default.conf"
