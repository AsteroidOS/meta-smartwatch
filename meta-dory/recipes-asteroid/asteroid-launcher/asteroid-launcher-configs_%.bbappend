FILESEXTRAPATHS:prepend:dory := "${THISDIR}/asteroid-launcher-configs:"
