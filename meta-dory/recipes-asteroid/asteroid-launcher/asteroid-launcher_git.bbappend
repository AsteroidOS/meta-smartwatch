FILESEXTRAPATHS_prepend_dory := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_dory = " file://default.conf"
