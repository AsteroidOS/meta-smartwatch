FILESEXTRAPATHS:prepend:dory := "${THISDIR}/${PN}:"
