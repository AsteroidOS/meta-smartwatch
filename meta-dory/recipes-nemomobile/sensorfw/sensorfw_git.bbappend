DEPENDS:append:dory = " libhybris "
