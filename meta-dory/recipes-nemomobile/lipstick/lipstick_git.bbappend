RDEPENDS:${PN}:append:dory = " qt6-qpa-hwcomposer-plugin "
