SRC_URI_append_dory = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
