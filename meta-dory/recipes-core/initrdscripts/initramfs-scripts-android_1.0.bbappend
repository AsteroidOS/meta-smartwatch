FILESEXTRAPATHS_prepend_dory := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_dory = "dory"
