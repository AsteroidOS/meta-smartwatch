FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://psplash-bar-img.png"
SPLASH_IMAGES = "file://psplash-poky-img.png;outsuffix=default"
