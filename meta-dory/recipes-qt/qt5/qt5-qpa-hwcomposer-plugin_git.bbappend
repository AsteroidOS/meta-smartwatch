SRC_URI_append_dory = " \
    file://003-Disable_hwcomposer_backend_v0.patch;striplevel=2 \
    file://004-Includes-sync.h-which-provides-sync_wait.patch;striplevel=2 \
"

