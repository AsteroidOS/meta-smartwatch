RDEPENDS:${PN}:append:medaka = " geoclue-provider-hybris-binder "
