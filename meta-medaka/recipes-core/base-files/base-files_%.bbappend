FILESEXTRAPATHS:prepend:medaka := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:medaka = "medaka"
