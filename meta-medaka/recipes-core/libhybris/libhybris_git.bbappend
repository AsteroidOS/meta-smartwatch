SRCREV:medaka = "a53eb0e292dd9528cf3825fec1d6ddb2cd4a8461"

EXTRA_OECONF:medaka = "--enable-arch=arm64"
