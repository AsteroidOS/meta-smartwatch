FILESEXTRAPATHS:prepend:medaka := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:medaka = " file://default.conf"
