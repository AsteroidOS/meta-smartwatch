FILESEXTRAPATHS:prepend:medaka := "${THISDIR}/asteroid-launcher-configs:"
