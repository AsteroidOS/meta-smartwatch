RDEPENDS:${PN}:append:medaka = " nfcd-binder-plugin "
