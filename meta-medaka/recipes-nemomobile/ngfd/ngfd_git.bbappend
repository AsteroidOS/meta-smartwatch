RDEPENDS:${PN}:append:medaka = " ngfd-plugin-droid-vibrator "
