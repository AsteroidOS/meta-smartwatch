RDEPENDS:${PN}:append:medaka = " qt5-qpa-hwcomposer-plugin "
