FILESEXTRAPATHS_prepend_lenok := "${THISDIR}/${PN}:"
