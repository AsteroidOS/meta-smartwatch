RDEPENDS:${PN}:append:lenok = " qt5-qpa-hwcomposer-plugin "
