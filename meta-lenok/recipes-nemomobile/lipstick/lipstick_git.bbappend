RDEPENDS:${PN}:append:lenok = " qt6-qpa-hwcomposer-plugin "
