RDEPENDS_${PN}_append_lenok = " ngfd-plugin-droid-vibrator "
