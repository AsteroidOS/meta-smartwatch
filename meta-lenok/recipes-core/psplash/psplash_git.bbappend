SPLASH_IMAGES = "file://psplash-img-280.png;outsuffix=default"
