RDEPENDS_${PN}_append_lenok = "qt5-feedback-haptics-droid-vibrator"
