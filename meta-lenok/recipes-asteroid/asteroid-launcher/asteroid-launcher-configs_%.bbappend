FILESEXTRAPATHS:prepend:lenok := "${THISDIR}/asteroid-launcher-configs:"
