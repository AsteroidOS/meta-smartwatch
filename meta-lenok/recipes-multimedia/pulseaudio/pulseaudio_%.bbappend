RDEPENDS_pulseaudio-server_append_lenok = "pulseaudio-modules-droid"
