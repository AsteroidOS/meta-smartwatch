SRC_URI_append_dory = " file://0003-droid-util-Use-a-mono-input-stream.patch"
