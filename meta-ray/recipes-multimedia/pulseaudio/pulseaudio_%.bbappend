RDEPENDS:pulseaudio-server:append:ray = " pulseaudio-modules-droid "
RDEPENDS:pulseaudio-server:append:firefish = " pulseaudio-modules-droid "
