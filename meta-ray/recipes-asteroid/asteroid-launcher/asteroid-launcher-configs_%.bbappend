FILESEXTRAPATHS:prepend:ray := "${THISDIR}/asteroid-launcher-configs:"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/asteroid-launcher-configs:"
