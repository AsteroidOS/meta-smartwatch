FILESEXTRAPATHS:prepend:ray := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:ray = " file://default.conf"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:firefish = " file://default.conf"
