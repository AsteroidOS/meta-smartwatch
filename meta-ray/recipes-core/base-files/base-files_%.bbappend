FILESEXTRAPATHS:prepend:ray := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:ray = "ray"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:firefish = "firefish"