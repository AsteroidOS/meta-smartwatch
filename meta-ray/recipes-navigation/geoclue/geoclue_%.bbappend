RDEPENDS:${PN}:append:ray = " geoclue-provider-hybris-binder "
RDEPENDS:${PN}:append:firefish = " geoclue-provider-hybris-binder "
