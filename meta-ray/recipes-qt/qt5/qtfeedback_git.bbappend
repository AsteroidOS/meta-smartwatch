RDEPENDS_${PN}_append_sturgeon = "qt5-feedback-haptics-droid-vibrator"
