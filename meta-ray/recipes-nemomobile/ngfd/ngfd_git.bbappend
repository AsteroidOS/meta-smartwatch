RDEPENDS_${PN}_append_sawshark = " ngfd-plugin-droid-vibrator "
