RDEPENDS:${PN}:append:ray = " nfcd-binder-plugin "

RDEPENDS:${PN}:append:firefish = " nfcd-binder-plugin "
