RDEPENDS:${PN}:append:ray = " qt6-qpa-hwcomposer-plugin "
RDEPENDS:${PN}:append:firefish = " qt6-qpa-hwcomposer-plugin "
