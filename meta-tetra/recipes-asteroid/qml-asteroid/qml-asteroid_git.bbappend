SRC_URI_append_tetra = " file://0001-Spinners-Disable-shaders-which-cause-all-sorts-of-pr.patch"
