FILESEXTRAPATHS:prepend:tetra := "${THISDIR}/qml-asteroid:"

SRC_URI:append:tetra = " file://0001-Spinners-Disable-shaders-which-cause-all-sorts-of-pr.patch"
