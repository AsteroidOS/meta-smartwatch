FILESEXTRAPATHS:prepend:tetra := "${THISDIR}/asteroid-launcher-configs:"
