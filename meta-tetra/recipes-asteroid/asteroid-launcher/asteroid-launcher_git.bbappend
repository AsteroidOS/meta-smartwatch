FILESEXTRAPATHS_prepend := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_tetra = " file://default.conf"
