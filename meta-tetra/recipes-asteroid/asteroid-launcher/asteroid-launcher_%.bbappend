FILESEXTRAPATHS:prepend:tetra := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:tetra = " file://default.conf"
