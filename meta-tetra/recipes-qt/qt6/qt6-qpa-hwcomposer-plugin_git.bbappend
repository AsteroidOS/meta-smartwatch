FILESEXTRAPATHS:prepend:tetra := "${THISDIR}/qt6-qpa-hwcomposer-plugin:"
SRC_URI:append:tetra = " file://0001-Adapt-to-what-tetra-s-hwcomposer-expects.patch;striplevel=2"
