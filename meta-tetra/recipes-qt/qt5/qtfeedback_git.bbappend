RDEPENDS_${PN}_append_tetra = "qt5-feedback-haptics-droid-vibrator"
