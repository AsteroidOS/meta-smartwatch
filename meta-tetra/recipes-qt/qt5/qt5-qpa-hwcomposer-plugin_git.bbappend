FILESEXTRAPATHS_prepend_tetra := "${THISDIR}/qt5-qpa-hwcomposer-plugin:"
SRC_URI_append_tetra = " file://0001-Adapt-to-what-tetra-s-hwcomposer-expects.patch;striplevel=2"
