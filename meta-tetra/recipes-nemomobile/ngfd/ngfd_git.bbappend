RDEPENDS_${PN}_append_tetra = " ngfd-plugin-droid-vibrator "
