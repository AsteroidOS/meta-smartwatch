RDEPENDS:${PN}:append:tetra = " qt6-qpa-hwcomposer-plugin "
