FILESEXTRAPATHS_prepend_tetra := "${THISDIR}/${PN}:"
