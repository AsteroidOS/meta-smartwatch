SRC_URI_append_tetra = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
