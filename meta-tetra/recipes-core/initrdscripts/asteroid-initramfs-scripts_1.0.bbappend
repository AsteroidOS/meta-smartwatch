FILESEXTRAPATHS:prepend:tetra := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:tetra = "tetra"
