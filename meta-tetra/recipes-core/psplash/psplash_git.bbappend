SPLASH_IMAGES = "file://psplash-img-320.png;outsuffix=default"
