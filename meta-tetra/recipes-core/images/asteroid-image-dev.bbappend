require generate-sparse-image.inc
