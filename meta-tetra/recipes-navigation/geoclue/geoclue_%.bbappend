RDEPENDS:${PN}:append:tetra = " geoclue-provider-hybris "
