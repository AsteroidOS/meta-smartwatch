RDEPENDS_${PN}_append_tetra = " geoclue-provider-hybris "
