RDEPENDS:${PN}:append:koi = " ngfd-plugin-droid-vibrator "
