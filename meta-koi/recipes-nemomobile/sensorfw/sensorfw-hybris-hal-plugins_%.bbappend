FILESEXTRAPATHS:prepend:koi := "${THISDIR}/sensorfw:"
SRC_URI:append:koi = " file://sensorfwd.service"
