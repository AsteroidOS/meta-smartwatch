RDEPENDS:${PN}:append:koi = " qt6-qpa-hwcomposer-plugin "
