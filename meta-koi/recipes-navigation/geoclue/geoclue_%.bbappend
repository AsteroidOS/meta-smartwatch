RDEPENDS:${PN}:append:koi = " geoclue-provider-hybris-hal "
