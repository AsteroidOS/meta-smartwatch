FILESEXTRAPATHS:prepend:koi := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:koi = " file://default.conf"
