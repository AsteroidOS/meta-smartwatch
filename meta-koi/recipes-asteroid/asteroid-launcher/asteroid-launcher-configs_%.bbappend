FILESEXTRAPATHS:prepend:koi := "${THISDIR}/asteroid-launcher-configs:"
