FILESEXTRAPATHS:prepend:swift := "${THISDIR}/${PN}:"
