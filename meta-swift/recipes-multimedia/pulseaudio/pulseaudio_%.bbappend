RDEPENDS_pulseaudio-server_append_swift = " pulseaudio-modules-droid "
