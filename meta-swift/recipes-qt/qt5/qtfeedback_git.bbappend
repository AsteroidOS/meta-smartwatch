RDEPENDS_${PN}_append_dory = "qt5-feedback-haptics-droid-vibrator"
