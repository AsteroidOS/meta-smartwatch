RDEPENDS:${PN}:append:swift = " ngfd-plugin-droid-vibrator "
