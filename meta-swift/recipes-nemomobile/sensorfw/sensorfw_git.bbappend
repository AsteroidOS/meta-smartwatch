DEPENDS:append:swift = " libhybris "
