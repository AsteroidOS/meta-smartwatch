RDEPENDS:${PN}:append:swift = " qt6-qpa-hwcomposer-plugin "
