FILESEXTRAPATHS:prepend:swift := "${THISDIR}/asteroid-launcher-configs:"