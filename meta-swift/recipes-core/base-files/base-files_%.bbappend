FILESEXTRAPATHS_prepend_swift := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_swift = "swift"
