FILESEXTRAPATHS:prepend:swift := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:swift = "swift"
