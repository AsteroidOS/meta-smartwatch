IMAGE_INSTALL:remove:smelt = "android-tools bash"
