FILESEXTRAPATHS:prepend:smelt := "${THISDIR}/${PN}:"
