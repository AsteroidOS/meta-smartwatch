RDEPENDS:${PN}:append:smelt = " qt6-qpa-hwcomposer-plugin "
