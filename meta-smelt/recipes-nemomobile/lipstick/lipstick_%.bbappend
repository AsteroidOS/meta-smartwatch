RDEPENDS:${PN}:append:smelt = " qt5-qpa-hwcomposer-plugin "
