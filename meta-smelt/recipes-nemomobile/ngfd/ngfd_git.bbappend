RDEPENDS:${PN}:append:smelt = " ngfd-plugin-droid-vibrator "
