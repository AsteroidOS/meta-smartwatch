SRC_URI_append_smelt = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
