RDEPENDS:pulseaudio-server:append:smelt = " pulseaudio-modules-droid "
