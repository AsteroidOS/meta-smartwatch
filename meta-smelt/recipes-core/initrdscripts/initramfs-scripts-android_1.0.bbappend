FILESEXTRAPATHS_prepend_smelt := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_smelt = "smelt"
