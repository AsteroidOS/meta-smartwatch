FILESEXTRAPATHS:prepend:smelt := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:smelt = " file://default.conf"
