FILESEXTRAPATHS:prepend:smelt := "${THISDIR}/asteroid-launcher-configs:"
