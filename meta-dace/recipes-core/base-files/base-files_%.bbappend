FILESEXTRAPATHS:prepend:dace := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:dace = "dace"
