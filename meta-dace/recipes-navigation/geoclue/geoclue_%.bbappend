RDEPENDS:${PN}:append:dace = " geoclue-provider-hybris-binder "
