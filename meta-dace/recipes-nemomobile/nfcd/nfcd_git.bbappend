RDEPENDS:${PN}:append:dace = " nfcd-binder-plugin "
