FILESEXTRAPATHS:prepend:dace := "${THISDIR}/asteroid-launcher-configs:"
