FILESEXTRAPATHS:prepend:catfish := "${THISDIR}/asteroid-launcher-configs:"
