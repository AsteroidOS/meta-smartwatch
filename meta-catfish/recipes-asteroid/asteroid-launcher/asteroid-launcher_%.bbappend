FILESEXTRAPATHS_prepend_sawshark := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_sawshark = " file://default.conf"
