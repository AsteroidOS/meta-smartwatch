RDEPENDS:${PN}:append:catfish = " ngfd-plugin-droid-vibrator "
