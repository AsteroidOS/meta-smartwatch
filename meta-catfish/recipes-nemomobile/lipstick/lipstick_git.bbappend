RDEPENDS:${PN}:append:catfish = " qt6-qpa-hwcomposer-plugin "
