RDEPENDS:${PN}:append:catfish = " qt5-qpa-hwcomposer-plugin "
