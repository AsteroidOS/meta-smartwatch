RDEPENDS:${PN}:append:catfish = " geoclue-provider-hybris-hal "
