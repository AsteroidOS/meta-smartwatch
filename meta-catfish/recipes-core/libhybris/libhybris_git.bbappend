SRCREV_sawfish = "9cadeefe224aa2387cc88c9d17a374df2f265ba8"

SRC_URI_remove_sawfish = "file://0001-Add-EGL_OPENGL_ES3_BIT_KHR-define.patch;patchdir=.."
