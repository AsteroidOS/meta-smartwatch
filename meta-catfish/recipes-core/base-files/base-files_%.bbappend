FILESEXTRAPATHS:prepend:catfish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:catfish = "catfish"
