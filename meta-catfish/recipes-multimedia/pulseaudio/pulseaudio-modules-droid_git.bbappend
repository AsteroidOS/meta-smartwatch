do_configure:prepend() {
	touch src/common/droid-util-51.h
}
