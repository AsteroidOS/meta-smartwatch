RDEPENDS:${PN}:append:hoki = " geoclue-provider-hybris-binder "
