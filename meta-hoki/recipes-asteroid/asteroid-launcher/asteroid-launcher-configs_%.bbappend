FILESEXTRAPATHS:prepend:hoki := "${THISDIR}/asteroid-launcher-configs:"
