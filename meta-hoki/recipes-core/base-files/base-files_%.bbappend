FILESEXTRAPATHS:prepend:hoki := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:hoki = "hoki"
