RDEPENDS:${PN}:append:hoki = " nfcd-binder-plugin "
