RDEPENDS:${PN}:append:hoki = " qt6-qpa-hwcomposer-plugin "
