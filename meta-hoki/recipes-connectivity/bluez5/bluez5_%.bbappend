FILESEXTRAPATHS:prepend:hoki := "${THISDIR}/bluez5:"
