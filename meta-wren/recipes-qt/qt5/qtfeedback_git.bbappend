RDEPENDS_${PN}_append_wren = "qt5-feedback-haptics-droid-vibrator"
