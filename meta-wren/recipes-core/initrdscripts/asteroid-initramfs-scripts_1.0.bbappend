FILESEXTRAPATHS:prepend:wren := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:wren = "wren"
