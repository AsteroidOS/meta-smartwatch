FILESEXTRAPATHS_prepend_sparrow := "${THISDIR}/${PN}:"
