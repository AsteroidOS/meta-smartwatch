FILESEXTRAPATHS_prepend_wren := "${THISDIR}/${PN}:"