RDEPENDS:${PN}:append:wren = " qt6-qpa-hwcomposer-plugin"
