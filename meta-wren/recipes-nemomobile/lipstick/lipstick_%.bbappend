RDEPENDS:${PN}:append:wren = " qt5-qpa-hwcomposer-plugin"
