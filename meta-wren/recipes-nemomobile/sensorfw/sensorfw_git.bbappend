DEPENDS_append_sparrow = "libhybris"
