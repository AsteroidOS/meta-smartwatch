RDEPENDS_${PN}_append_wren = " ngfd-plugin-droid-vibrator "
