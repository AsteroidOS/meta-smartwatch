FILESEXTRAPATHS:prepend:sprat := "${THISDIR}/${PN}:"
