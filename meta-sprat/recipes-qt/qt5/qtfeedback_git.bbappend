RDEPENDS_${PN}_append_sprat = "qt5-feedback-haptics-droid-vibrator"
