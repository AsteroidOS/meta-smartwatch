FILESEXTRAPATHS:prepend:sprat := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:sprat = "sprat"
