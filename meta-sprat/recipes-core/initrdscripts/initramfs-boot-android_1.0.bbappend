FILESEXTRAPATHS_prepend_sprat := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_sprat = "sprat"
