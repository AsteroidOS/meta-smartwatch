FILESEXTRAPATHS:prepend:sprat := "${THISDIR}/asteroid-launcher-configs:"
