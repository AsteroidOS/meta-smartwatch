RDEPENDS_${PN}_append_sprat = " ngfd-plugin-droid-vibrator "
