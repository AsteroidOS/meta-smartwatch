RDEPENDS:${PN}:append:sprat = " qt6-qpa-hwcomposer-plugin "
