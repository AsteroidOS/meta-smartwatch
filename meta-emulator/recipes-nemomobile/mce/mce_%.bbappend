FILESEXTRAPATHS:prepend:emulator := "${THISDIR}/mce:"
SRC_URI:append:emulator = " file://0001-Keep-screen-on-by-default-on-emulator.patch "
