PACKAGECONFIG:append:emulator = " gallium"
GALLIUMDRIVERS:append:emulator = ",virgl"
