FILESEXTRAPATHS:prepend:emulator := "${THISDIR}/qml-asteroid:"
SRC_URI:append:emulator = " file://0001-Spinners-Disable-shaders-which-cause-all-sorts-of-pr.patch"
