RDEPENDS_${PN} += "nemo-qtmultimedia-plugins"
