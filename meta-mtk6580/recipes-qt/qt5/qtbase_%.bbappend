PACKAGECONFIG_remove = "mtdev"
PACKAGECONFIG_append = " libinput"
