PACKAGECONFIG:append:harmony = " libinput"
PACKAGECONFIG:append:inharmony = " libinput"
