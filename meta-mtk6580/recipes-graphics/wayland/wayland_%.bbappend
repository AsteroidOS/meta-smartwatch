SRC_URI_append_harmony = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
SRC_URI_append_inharmony = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
