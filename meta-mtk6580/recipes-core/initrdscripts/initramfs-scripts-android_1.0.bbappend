FILESEXTRAPATHS:prepend:harmony := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:harmony = "harmony"

FILESEXTRAPATHS:prepend:inharmony := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:inharmony = "inharmony"
