FILESEXTRAPATHS_prepend_harmony := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_harmony = "harmony"
