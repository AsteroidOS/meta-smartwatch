RDEPENDS:${PN}:append:harmony = " geoclue-provider-hybris "
RDEPENDS:${PN}:append:inharmony = " geoclue-provider-hybris "
