FILESEXTRAPATHS_prepend_harmony := "${THISDIR}/${PN}:"
