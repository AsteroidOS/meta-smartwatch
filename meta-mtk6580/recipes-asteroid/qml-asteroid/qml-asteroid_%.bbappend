FILESEXTRAPATHS_prepend_harmony := "${THISDIR}/qml-asteroid:"
SRC_URI_append_harmony = " file://0001-Application-Rotate-screen-for-harmony.patch"
SRC_URI_append_harmony = " file://0001-Spinners-Disable-shaders-which-cause-all-sorts-of-pr.patch"
