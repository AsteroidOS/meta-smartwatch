FILESEXTRAPATHS:prepend:harmony := "${THISDIR}/asteroid-launcher-configs:"

FILESEXTRAPATHS:prepend:inharmony := "${THISDIR}/asteroid-launcher-configs:"

