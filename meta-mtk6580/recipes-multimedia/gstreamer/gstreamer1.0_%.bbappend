RDEPENDS_${PN}_append_harmony = " gst-droid "
