FILESEXTRAPATHS:prepend:aurora := "${THISDIR}/asteroid-launcher-configs:"
