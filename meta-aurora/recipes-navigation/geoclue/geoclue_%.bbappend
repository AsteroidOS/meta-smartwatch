RDEPENDS:${PN}:append:aurora = " geoclue-provider-hybris-binder "
