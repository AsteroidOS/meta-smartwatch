FILESEXTRAPATHS:prepend:aurora := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:aurora = "aurora"
