RDEPENDS:${PN}:append:aurora = " nfcd-binder-plugin "
