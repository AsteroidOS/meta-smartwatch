RDEPENDS:${PN}:append:aurora = " qt6-qpa-hwcomposer-plugin "
