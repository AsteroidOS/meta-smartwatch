FILESEXTRAPATHS:prepend:triggerfish := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:triggerfish = " file://default.conf"
