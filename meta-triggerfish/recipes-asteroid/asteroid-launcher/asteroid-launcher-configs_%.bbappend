FILESEXTRAPATHS:prepend:triggerfish := "${THISDIR}/asteroid-launcher-configs:"