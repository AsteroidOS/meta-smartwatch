RDEPENDS:${PN}:append:triggerfish = " geoclue-provider-hybris-binder "
