RDEPENDS:${PN}:append:triggerfish = " qt6-qpa-hwcomposer-plugin "
