RDEPENDS:${PN}:append:triggerfish = " ngfd-plugin-droid-vibrator "
