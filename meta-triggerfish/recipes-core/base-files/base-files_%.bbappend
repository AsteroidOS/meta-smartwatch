FILESEXTRAPATHS:prepend:triggerfish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:triggerfish = "triggerfish"
