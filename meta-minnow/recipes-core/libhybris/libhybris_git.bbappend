SRC_URI:append:minnow = " file://0001-Report-support-for-only-2.0-instead-of-3.0.patch;striplevel=2"
