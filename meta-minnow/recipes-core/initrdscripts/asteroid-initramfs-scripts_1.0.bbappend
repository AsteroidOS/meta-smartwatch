FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:minnow = "minnow"
