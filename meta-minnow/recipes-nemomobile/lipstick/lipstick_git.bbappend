RDEPENDS:${PN}:append:minnow = " qt6-qpa-hwcomposer-plugin "
