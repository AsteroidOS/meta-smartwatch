RDEPENDS:${PN}:append:minnow = " ngfd-plugin-droid-vibrator "
