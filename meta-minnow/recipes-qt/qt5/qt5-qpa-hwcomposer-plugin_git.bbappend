SRC_URI:append:minnow = " \
    file://0002-Add-QCOM_BSP-define-switch.patch;striplevel=2 \
    file://004-Includes-sync.h-which-provides-sync_wait.patch;striplevel=2 \
"
