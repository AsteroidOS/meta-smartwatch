FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/${PN}:"
