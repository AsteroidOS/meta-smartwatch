RDEPENDS:pulseaudio-server:remove:minnow = " pulseaudio-modules-droid-jb2q "
