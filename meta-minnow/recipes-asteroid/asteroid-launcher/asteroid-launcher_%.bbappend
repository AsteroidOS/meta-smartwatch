FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:minnow = " file://default.conf"
