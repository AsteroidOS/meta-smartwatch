FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/asteroid-launcher-configs:"
