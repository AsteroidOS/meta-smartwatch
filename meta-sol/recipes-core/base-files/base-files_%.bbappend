FILESEXTRAPATHS:prepend:sol := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:sol = "sol"
