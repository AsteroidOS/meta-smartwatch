FILESEXTRAPATHS:prepend:sol := "${THISDIR}/asteroid-launcher-configs:"
