FILESEXTRAPATHS:prepend:sturgeon := "${THISDIR}/${PN}:"
