FILESEXTRAPATHS:prepend:sturgeon := "${THISDIR}/asteroid-launcher-configs:"
