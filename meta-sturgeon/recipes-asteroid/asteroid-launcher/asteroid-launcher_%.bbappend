FILESEXTRAPATHS:prepend:sturgeon := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:sturgeon = " file://default.conf"
