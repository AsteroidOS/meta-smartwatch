RDEPENDS:${PN}:append:sturgeon = " qt5-qpa-hwcomposer-plugin "
