RDEPENDS:${PN}:append:sturgeon = " qt6-qpa-hwcomposer-plugin "
