RDEPENDS:${PN}:append:sturgeon = " ngfd-plugin-droid-vibrator "
