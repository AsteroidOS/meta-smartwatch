RDEPENDS:pulseaudio-server:append:sturgeon = " pulseaudio-modules-droid "
