RDEPENDS:pulseaudio-server:remove:nemo= " pulseaudio-modules-droid-jb2q "
