FILESEXTRAPATHS:prepend:nemo := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:nemo = " file://default.conf"
