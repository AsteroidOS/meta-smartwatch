FILESEXTRAPATHS:prepend:nemo := "${THISDIR}/asteroid-launcher-configs:"
