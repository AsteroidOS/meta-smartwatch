RDEPENDS:${PN}:append:nemo = " ngfd-plugin-droid-vibrator "
