RDEPENDS:${PN}:append:nemo = " qt6-qpa-hwcomposer-plugin "
