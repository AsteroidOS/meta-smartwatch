FILESEXTRAPATHS:prepend:nemo := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINEL:nemo = "nemo"
