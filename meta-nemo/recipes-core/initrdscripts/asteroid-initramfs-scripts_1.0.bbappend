FILESEXTRAPATHS:prepend:nemo := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:nemo = "nemo"
