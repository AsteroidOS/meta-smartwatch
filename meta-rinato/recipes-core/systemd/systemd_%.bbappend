# This watch has a sufficiently new kernel that it's supported
PACKAGECONFIG:append:rinato = " pstore "
