FILESEXTRAPATHS:prepend:rinato := "${THISDIR}/${PN}:"

SRC_URI:append:rinato = " file://0001-Display-Hack-to-put-screen-to-sleep-on-Rinato.patch "

