PACKAGECONFIG:append:rinato = " kmsro lima"
