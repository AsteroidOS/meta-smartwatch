FILESEXTRAPATHS_prepend_anthias := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_anthias = "anthias"
