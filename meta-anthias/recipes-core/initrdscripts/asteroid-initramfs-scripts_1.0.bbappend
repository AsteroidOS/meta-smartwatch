FILESEXTRAPATHS:prepend:anthias := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:anthias = "anthias"
