FILESEXTRAPATHS:prepend:anthias := "${THISDIR}/${PN}:"
