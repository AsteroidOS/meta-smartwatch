RDEPENDS_${PN}_append_anthias = "qt5-feedback-haptics-droid-vibrator"
