FILESEXTRAPATHS:prepend:anthias := "${THISDIR}/asteroid-launcher-configs:"
