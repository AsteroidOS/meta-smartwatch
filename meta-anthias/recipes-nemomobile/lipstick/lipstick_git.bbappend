RDEPENDS:${PN}:append:anthias = " qt6-qpa-hwcomposer-plugin "
