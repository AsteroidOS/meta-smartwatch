RDEPENDS:${PN}:append:anthias = " qt5-qpa-hwcomposer-plugin "
