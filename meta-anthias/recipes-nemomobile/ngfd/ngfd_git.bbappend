RDEPENDS:${PN}:append:anthias = " ngfd-plugin-droid-vibrator "
