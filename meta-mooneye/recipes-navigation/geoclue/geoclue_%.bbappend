RDEPENDS:${PN}:append:mooneye = " geoclue-provider-hybris-hal "
