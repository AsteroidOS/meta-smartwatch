FILESEXTRAPATHS:prepend:mooneye := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:mooneye = "mooneye"
