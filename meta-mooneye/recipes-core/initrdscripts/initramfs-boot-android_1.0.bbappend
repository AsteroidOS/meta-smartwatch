FILESEXTRAPATHS_prepend_mooneye := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_mooneye = "mooneye"
