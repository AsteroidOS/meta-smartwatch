RDEPENDS_${PN}_append_mooneye = " ngfd-plugin-droid-vibrator "
