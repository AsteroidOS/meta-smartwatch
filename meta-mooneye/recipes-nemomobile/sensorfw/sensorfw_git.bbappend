DEPENDS:append:mooneye = " libhybris "
