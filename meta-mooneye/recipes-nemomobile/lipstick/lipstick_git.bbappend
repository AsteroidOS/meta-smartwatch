RDEPENDS:${PN}:append:mooneye = " qt6-qpa-hwcomposer-plugin "
