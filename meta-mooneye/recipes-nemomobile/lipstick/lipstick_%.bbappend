RDEPENDS:${PN}:append:mooneye = " qt5-qpa-hwcomposer-plugin "
