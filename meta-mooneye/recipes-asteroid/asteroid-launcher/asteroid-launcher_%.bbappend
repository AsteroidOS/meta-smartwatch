FILESEXTRAPATHS_prepend_mooneye := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_mooneye = " file://default.conf"
