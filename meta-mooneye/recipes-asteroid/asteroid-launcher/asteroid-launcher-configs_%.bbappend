FILESEXTRAPATHS:prepend:mooneye := "${THISDIR}/asteroid-launcher-configs:"

