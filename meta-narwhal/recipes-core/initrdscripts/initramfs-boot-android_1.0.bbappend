FILESEXTRAPATHS_prepend_sturgeon := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_sturgeon = "sturgeon"
