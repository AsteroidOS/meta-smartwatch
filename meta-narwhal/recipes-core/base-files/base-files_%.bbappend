FILESEXTRAPATHS:prepend:narwhal := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:narwhal = "narwhal"
