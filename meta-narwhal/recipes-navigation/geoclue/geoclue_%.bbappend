RDEPENDS:${PN}:append:narwhal = " geoclue-provider-hybris "
