FILESEXTRAPATHS:prepend:narwhal := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:narwhal = " file://default.conf"
