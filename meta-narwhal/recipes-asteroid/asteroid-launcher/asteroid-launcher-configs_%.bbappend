FILESEXTRAPATHS:prepend:narwhal := "${THISDIR}/asteroid-launcher-configs:"
