RDEPENDS:${PN}:append:narwhal = " qt6-qpa-hwcomposer-plugin "
