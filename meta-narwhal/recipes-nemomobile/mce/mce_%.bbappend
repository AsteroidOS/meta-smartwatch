FILESEXTRAPATHS:prepend:narwhal := "${THISDIR}/mce:"
