RDEPENDS:${PN}:append:narwhal = " ngfd-plugin-droid-vibrator "
