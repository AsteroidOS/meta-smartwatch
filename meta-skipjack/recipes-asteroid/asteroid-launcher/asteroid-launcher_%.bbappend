FILESEXTRAPATHS_prepend_skipjack := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_skipjack = " file://default.conf"
