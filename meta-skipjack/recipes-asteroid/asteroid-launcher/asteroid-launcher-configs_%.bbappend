FILESEXTRAPATHS:prepend:skipjack := "${THISDIR}/asteroid-launcher-configs:"
