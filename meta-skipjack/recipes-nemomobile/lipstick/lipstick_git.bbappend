RDEPENDS:${PN}:append:skipjack = " qt6-qpa-hwcomposer-plugin "
