FILESEXTRAPATHS_prepend_skipjack := "${THISDIR}/usb-moded:"
