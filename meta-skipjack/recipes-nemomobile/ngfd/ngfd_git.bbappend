RDEPENDS_${PN}_append_skipjack = " ngfd-plugin-droid-vibrator "
