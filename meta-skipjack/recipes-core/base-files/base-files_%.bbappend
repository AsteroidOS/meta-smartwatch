FILESEXTRAPATHS:prepend:skipjack := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:skipjack = "skipjack"
