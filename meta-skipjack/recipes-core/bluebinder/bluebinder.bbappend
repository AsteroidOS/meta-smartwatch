FILESEXTRAPATHS:prepend:skipjack := "${THISDIR}/bluebinder:"

LIC_FILES_CHKSUM:skipjack = "file://bluebinder.c;beginline=1;endline=29;md5=a5ec0cf2a3c5b266b4598f748dee0a39"

SRCREV:skipjack = "632c3fb05010538b805a59ab23e6a4931989428f"
