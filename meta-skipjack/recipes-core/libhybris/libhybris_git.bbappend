SRC_URI_append_skipjack = " file://0002-egl-Adapt-wayland-egl-to-upstream-and-use-upstream-w.patch;striplevel=2 \
                            file://0003-hybris-gles-Add-GLESv3-headers.patch;striplevel=2 "
